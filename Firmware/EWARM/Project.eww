<?xml version="1.0" encoding="UTF-8"?>
<workspace>
  <project>
    <path>$WS_DIR$\AMS_MB_F401RC.ewp</path>
  </project>
  <batchBuild />
</workspace>
